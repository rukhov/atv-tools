options:
  parameters:
    author: rukhov
    generate_options: qt_gui
    id: test_cartoon_1
    output_language: python
    title: test_cartoon_1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: ATV_TvDecoder_0
  id: ATV_TvDecoder
  parameters:
    path: atv
    port: '8554'
    samp_rate: samp_rate
    standard: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rukhov/projects/analog-tv-tools/analog-tv-tools/test-data/cartoon-test-video-4-16000000Hz.i16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.333'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', ATV_TvDecoder_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', ATV_TvDecoder_0, '0']
- [blocks_short_to_float_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
