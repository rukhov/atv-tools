options:
  parameters:
    author: rukhov
    generate_options: qt_gui
    id: test_cartoon_1
    output_language: python
    title: test_cartoon_1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ATV_TvDecoder_0
  id: ATV_TvDecoder
  parameters:
    path: atv
    port: '8544'
    samp_rate: samp_rate
    standard: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', ATV_TvDecoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
